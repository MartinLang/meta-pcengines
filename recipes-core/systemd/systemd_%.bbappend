# needed for the IPMasquerade flag in the br0 network file
# to be working correctly
PACKAGECONFIG_append = " iptc"
