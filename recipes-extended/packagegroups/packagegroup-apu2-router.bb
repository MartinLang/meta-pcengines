inherit packagegroup

RDEPENDS_${PN} = " \
    apu2-router-bridges \
    crda \
    dnsmasq \
    hostapd \
    iperf3 \
    iw \
    kernel-modules \
    linux-firmware-ath10k \
"
